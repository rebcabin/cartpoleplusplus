Commit message: safety commit

File: models/pole1.urdf (robot description, URDF)
Before this commit: robot pole2, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=0.010 0.010 0.500; visual box size=0.010 0.010 0.500
